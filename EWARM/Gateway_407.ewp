# IAR project Gateway_407.ewp, settings and files
configuration Gateway_407 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Core/Ethernet; ../Core/Cli; ../Core/Qr; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Drivers/Flash; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../ThirdParty/FreeRTOS/Source; ../ThirdParty/FreeRTOS/Source/include; ../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../ThirdParty/FreeRTOS-Plus-Cli; ../ThirdParty/FreeRTOS-Plus-TCP/source/portable/Compiler/IAR; ../ThirdParty/FreeRTOS-Plus-TCP/source/include; ../ThirdParty/FreeRTOS-Plus-TCP/source/portable/NetworkInterface/include; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc; ../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM4F
  OBJCOPY.OOCOutputFile: Gateway_407.hex
  ILINK.IlinkOutputFile: Gateway_407.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: dma.c gpio.c main.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c tim.c usart.c
  group Application/User/Core/Cli
    ../Core/Cli/: cli.c cli.h cli_helper.c
  group Application/User/Core/Ethernet
    ../Core/Ethernet/: eth.h eth_helper.c eth_init.c
  group Application/User/Core/include
    ../Core/Inc/: AppConfig.h FreeRTOSConfig.h FreeRTOSIPConfig.h gpio.h main.h spi.h stm32_assert.h stm32f4xx_hal_conf.h stm32f4xx_it.h tim.h
  group Application/User/Core/Qr
    ../Core/Qr/: qr.c qr.h
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/Flash
    ../Drivers/Flash/: flash.c flash.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_dma.c stm32f4xx_ll_exti.c stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group ThirdParty/FreeRTOS
    ../ThirdParty/FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group ThirdParty/FreeRTOS/portable
    ../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../ThirdParty/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group ThirdParty/FreeRTOS-Plu-Cli
    ../ThirdParty/FreeRTOS-Plus-Cli/: FreeRTOS_CLI.c FreeRTOS_CLI.h
  group ThirdParty/FreeRTOS-Plus-TCP
    ../ThirdParty/FreeRTOS-Plus-TCP/source/: FreeRTOS_ARP.c FreeRTOS_BitConfig.c FreeRTOS_DHCP.c FreeRTOS_DHCPv6.c FreeRTOS_DNS.c FreeRTOS_DNS_Cache.c FreeRTOS_DNS_Callback.c FreeRTOS_DNS_Networking.c FreeRTOS_DNS_Parser.c FreeRTOS_ICMP.c FreeRTOS_IP.c FreeRTOS_IP_Timers.c FreeRTOS_IP_Utils.c FreeRTOS_IPv4.c FreeRTOS_IPv4_Sockets.c FreeRTOS_IPv4_Utils.c FreeRTOS_IPv6.c FreeRTOS_IPv6_Sockets.c FreeRTOS_IPv6_Utils.c FreeRTOS_ND.c FreeRTOS_RA.c FreeRTOS_Routing.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_IP_IPv4.c FreeRTOS_TCP_IP_IPv6.c FreeRTOS_TCP_Reception.c FreeRTOS_TCP_State_Handling.c FreeRTOS_TCP_State_Handling_IPv4.c FreeRTOS_TCP_State_Handling_IPv6.c FreeRTOS_TCP_Transmission.c FreeRTOS_TCP_Transmission_IPv4.c FreeRTOS_TCP_Transmission_IPv6.c FreeRTOS_TCP_Utils.c FreeRTOS_TCP_Utils_IPv4.c FreeRTOS_TCP_Utils_IPv6.c FreeRTOS_TCP_WIN.c FreeRTOS_Tiny_TCP.c FreeRTOS_UDP_IP.c FreeRTOS_UDP_IPv4.c FreeRTOS_UDP_IPv6.c
  group ThirdParty/FreeRTOS-Plus-TCP/portable
    ../ThirdParty/FreeRTOS-Plus-TCP/source/portable/BufferManagement/: BufferAllocation_2.c
    ../ThirdParty/FreeRTOS-Plus-TCP/source/portable/NetworkInterface/STM32Fxx/: NetworkInterface.c stm32fxx_hal_eth.c
    ../ThirdParty/FreeRTOS-Plus-TCP/source/portable/NetworkInterface/Common/: phyHandling.c
